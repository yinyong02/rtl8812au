## Kconfig
```kconfig
config RTL88XXAU
	tristate "Realtek 88XXau USB WiFi"
	depends on USB
	select WIRELESS_EXT
	help
	  Help message of RTL88XXAU
```
